Commit message: Conflict fix

File: src/vehicle_configuration/models/vehicle_model/urdf/sd_env200.urdf (robot description, URDF)
Before this commit: robot van, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename= scale=0.01 0.01 0.01
